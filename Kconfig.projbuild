## Kconfig.projbuild
```kconfig
menu "Component drv_fan Configuration"

    config DRV_FAN_USE
        bool "Use drv_fan component"
        default y
        
endmenu
```
